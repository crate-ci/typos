LICENSE:${PN} = "GPL-2.0.only"; FOO:pn-myrecipe = "myrecipe-specific value"
